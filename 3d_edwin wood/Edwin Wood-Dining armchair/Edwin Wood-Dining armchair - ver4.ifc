Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Edwin Wood-Dining armchair - ver4.ifc
Time: 2025-11-27T16:03:21
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (8)
Name
 | Edwin Wood-Dining armchair_0 - ObjectType: SketchupGroup
 | Edwin Wood-Dining armchair_1 - ObjectType: SketchupGroup
 | Edwin Wood-Dining armchair_2 - ObjectType: SketchupGroup
 | Edwin Wood-Dining armchair_3 - ObjectType: SketchupGroup
 | Edwin Wood-Dining armchair_4 - ObjectType: SketchupGroup
 | Edwin Wood-Dining armchair_5 - ObjectType: SketchupGroup
 | Edwin Wood-Dining armchair_6 - ObjectType: SketchupGroup
 | Edwin Wood-Dining armchair_7 - ObjectType: SketchupGroup
